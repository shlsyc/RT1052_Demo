# Keil uVision project RT1052_Demo.uvprojx, settings and files
target NorFlash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1052_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6A,SDRAM_MPU_INIT
  c misc: --library_interface=armcc  --library_type=standardlib   --diag_suppress=66,1296,186,815,188,111
  c include: ../../Lib/RTLib;../../Lib/Cmsis;../../User/App;../../User/HardWare;../../Lib/rt-thread;../../Lib/rt-thread/include;../../Lib/rt-thread/components/drivers/include;../../Lib/rt-thread/components/finsh;../../Lib/rt-thread/components/libc/compilers/armlibc;../../Lib/rt-thread/components/net/lwip-2.0.2/src;../../Lib/rt-thread/components/net/lwip-2.0.2/src/include;../../Lib/rt-thread/components/net/lwip-2.0.2/src/include/ipv4;../../Lib/rt-thread/components/net/lwip-2.0.2/src/arch/include;../../Lib/rt-thread/components/net/lwip-2.0.2/src/include/netif;../../Lib/rt-thread/components/net/lwip-2.0.2/src/include/posix;../../Lib/rt-thread/components/dfs/include;../../Lib/rt-thread/components/dfs/filesystems/devfs;../../Lib/rt-thread/components/dfs/filesystems/elmfat;../../Lib/lvgl;../../Lib/lv_port;../../Lib/lv_examples
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor.scf
  group Startup
    ../../Lib/Startup/arm/: startup_MIMXRT1052.s
  group Cmsis
    ../../Lib/Cmsis/: system_MIMXRT1052.c
  group RTLib
    ../../Lib/RTLib/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_wdog.c fsl_elcdif.c fsl_pxp.c fsl_lpi2c.c
  group App
    ../../User/App/: main.c SysConf.c
  group Drivers
    ../../User/HardWare/: Hal_Led.c Hal_Lcd.c Hal_Lcd_Port.c Touch_GT9xx.c Hal_I2C.c Hal_Touch.c drv_uart.c board.c drv_sdram.c
  group Cortex_Port
    ../../Lib/rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpuport.c
    ../../Lib/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Kernel
    ../../Lib/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group Filesystem
    ../../Lib/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../Lib/rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../Lib/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../Lib/rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../Lib/rt-thread/components/drivers/serial/: serial.c
    ../../Lib/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../Lib/rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group lwIP
    ../../Lib/rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../Lib/rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Lib/rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Lib/rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../Lib/rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group libc
    ../../Lib/rt-thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group lv_core
    ../../Lib/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../../Lib/lvgl/lv_draw/: lv_draw.c lv_draw_rbasic.c lv_draw_vbasic.c
  group lv_hal
    ../../Lib/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../../Lib/lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_trigo.c lv_txt.c lv_ufs.c lv_code_convert.c
  group lv_objx
    ../../Lib/lvgl/lv_objx/: lv_bar.c lv_btn.c lv_btnm.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lv_themes
    ../../Lib/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_font
    ../../Lib/lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_songti_20.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lv_examples
    ../../Lib/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../../Lib/lv_examples/lv_tests/lv_test_theme/: lv_test_theme.c
  group lv_port
    ../../Lib/lv_port/: lv_porting.c
target SDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: RT1052_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SDRAM_MPU_INIT,CPU_MIMXRT1052DVL6A
  c misc: as above
  c include: as above
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_sdram.scf
